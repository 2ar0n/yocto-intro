FILESEXTRAPATHS:prepend:aarons-distro := "${THISDIR}/files:"

SPLASH_IMAGES:aarons-distro = "file://psplash-aarons-distro-img.h;outsuffix=aarons-distro"
